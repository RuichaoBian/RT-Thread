# Keil uVision project project.uvproj, settings and files
target project (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: NUC240VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: project
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Libraries\Device\Nuvoton;..\..\components\finsh;.\Libraries\CMSIS\Include;.\Libraries\StdDriver\inc;..\..\include;.\APP;.\Drivers;..\..\components\drivers\include;..\..\components\drivers\include\drivers;..\nuvoton_nuc240;.\Libraries\Device\Nuvoton\NUC230_240\Include;..\..\include;..\..\components\drivers\usb\usbdevice\class
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\project.sct
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Applications
    ./APP/: app.c startup.c hid_kb.c USB_test.c
  group Drivers
    ./Drivers/: board.c usart.c led.c descriptors.c usb.c
    ../../components/drivers/usb/usbdevice/core/: usbdevice.c core.c
  group NUC240_StdPeriph
    ./Libraries/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
    ./Libraries/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ./Libraries/StdDriver/src/: acmp.c adc.c can.c clk.c crc.c ebi.c fmc.c gpio.c hid_mousekeyboard.c i2c.c i2s.c pdma.c ps2.c pwm.c rtc.c sc.c scuart.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c thread.c src_timer.c
  group CORTEX-M0
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Components
    ../../src/: components.c
