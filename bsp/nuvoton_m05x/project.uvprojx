# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: INIT_SYSCLK_AT_BOOTING
  c include: .;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;Libraries\CMSIS\Include;Libraries\CMSIS\Nuvoton\M051Series\Include;Libraries\StdDriver\inc;applications;drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\nuvoton_m05x.sct
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: startup.c
  group Drivers
    drivers/: board.c led.c usart.c
    ./drivers/: printf.c
  group M05X_StdPeriph
    Libraries/CMSIS/Nuvoton/M051Series/Source/: system_M051Series.c
    Libraries/StdDriver/src/: acmp.c adc.c clk.c ebi.c fmc.c gpio.c i2c.c pwm.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
    Libraries/CMSIS/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group CORTEX-M0
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../../src/: components.c
